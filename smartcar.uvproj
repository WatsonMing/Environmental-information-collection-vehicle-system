# Keil uVision project smartcar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: smartcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c moto.c ultrasonic.c nokia5110.c GPIO_UART.c delay.c DHT11.c
